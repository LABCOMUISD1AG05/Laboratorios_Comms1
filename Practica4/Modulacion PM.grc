options:
  parameters:
    author: JuanSarmiento_SergioUribe
    copyright: UIS
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: EnvolventeComplejaPM_0
  id: EnvolventeComplejaPM
  parameters:
    Ac: Ac
    Kp: kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [EnvolventeComplejaPM_0, '0', blocks_complex_to_mag_0, '0']
- [EnvolventeComplejaPM_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaPM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaPM_0, '0']
- [blocks_complex_to_mag_0, '0', CalculoPotenciaComunicaciones_0, '0']

metadata:
  file_format: 1
