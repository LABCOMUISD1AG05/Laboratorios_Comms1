options:
  parameters:
    author: JuanSarmiento_SergioUribe
    copyright: JuanSarmiento_SergioUribe
    generate_options: qt_gui
    id: transAM
    output_language: python
    title: Transistor AM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '0.3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud  modulada
    orient: Qt.Horizontal
    start: '0'
    step: '100e-6'
    stop: '3'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: ka
    orient: Qt.Horizontal
    start: '0'
    step: '100e-6'
    stop: '3'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: envolv_compleja_dsb_0
  id: envolv_compleja_dsb
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 50e6
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', envolv_compleja_dsb_0, '0']
- [envolv_compleja_dsb_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
